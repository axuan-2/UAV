# Keil uVision project CarryPilot.uvprojx, settings and files
target CarryPilot_LaunchPad_V4.0.3 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CarryPilot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1 __USE_ANSI_EXAMPLE_RAND
  c misc: --wchar32
  c include: .\Libraries\inc;.\WP_Ctrl;.\WP_Src;.\User;.\Libraries\utils;.\Libraries\driverlib;.\WP_Src\VL53L1X\core;.\WP_Src\VL53L1X;.\User\MY_anonymous;.\User\cjson
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Library
    ./Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group User
    ./User/: Headfile.h main.c startup_rvmdk.S
    ./Libraries/utils/: uartstdio.c
  group CP_Src
    ./WP_Src/: Calibration.c Bling.c Filter.c GPS.c IST8310.c Key.c ICM2068X.c myiic.c OLED.c OpticalFlow_LC306.c PID.c PPM.c RC.c Ringbuf.c Schedule.c SINS.c SPL06.c Time.c Time_Cnt.c US_100.c SYSTEM.c Usart.c WP_ADC.c wp_flash.c WP_Math.c WP_PWM.c ssd1306.c RDroneSudio.c Soft_I2C.c ICM20689.c QMC5883.c tfmini.c tfmini.h LCD_ST7789.c NCLink.c MMC3630.c VL53L1X.c TOPSensor.c Reserved_IO.c Reserved_Serialport.c
    ./WP_Src/VL53L1X/: vl53l1_platform.c vl53l1x_i2c.c
    ./WP_Ctrl/: OpticalFlow_Control.c
    ./User/MY_anonymous/: MY_anonymous.c
    ./User/cjson/: cJSON.c
  group CP_Ctrl
    ./WP_Ctrl/: control_althold.c CalibrationRoutines.c control_land.c control_poshold.c WP_Ctrl.c Earth_Declination.c License.c NamelessCorun_OpticalFlow.c NamelessCotrun_SDK.c Sensor.c Compass.c Temperature_Ctrl.c Developer_Mode.c ADC_Button.c DIY_OP.c
  group CP_Src/VL53L1X/core
    ./WP_Src/VL53L1X/core/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
